# Keil uVision project Project.uvprojx, settings and files
target STM32F103C8 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD
  c include: .\User;.\Comms;.\Protocol;.\Core;.\System;.\Fwlib\inc;.\FreeRTOS\include;.\FreeRTOS\portable\RVDS\ARM_CM3
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ./User/: main.c stm32f10x_it.c
  group Comms
    ./Comms/: ringbuffer.c uart_dma.c uart_port.c uart_api.c
  group Protocol
    ./Protocol/: frame_protocol.c cmd_handler.c
  group Core
    ./Core/: core_cm3.c startup_stm32f10x_md.s
    ./System/: system_stm32f10x.c
  group Fwlib
    ./Fwlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group FreeRTOS_Kernel
    ./FreeRTOS/: tasks.c queue.c list.c timers.c event_groups.c croutine.c stream_buffer.c
  group FreeRTOS_Port
    ./FreeRTOS/portable/RVDS/ARM_CM3/: port.c
    ./FreeRTOS/portable/MemMang/: heap_4.c
software components: CMSIS:CORE 6.2.0
